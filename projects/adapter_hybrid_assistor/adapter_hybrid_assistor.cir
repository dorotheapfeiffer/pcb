.title KiCad schematic
HDMI_1 H_DOUT_M1_1P GNDREF H_DOUT_M1_1N H_DOUT_M2_1P GNDREF H_DOUT_M2_1N H_BCLK_1P GNDREF H_BCLK_1N H_TRG_1P GNDREF H_TRG_1N NC_01 NC_02 H_SCL0B_1 H_SDA0B_1 GNDREF Net-_HDMI_1-Pad18_ NC_03 GNDREF HDMI_A_1.4
J1 Net-_C1-Pad1_ NC_04 NC_05 NC_06 GNDREF NC_07 USB_B_Micro
HDMI_2 H_DOUT_M1_2P GNDREF H_DOUT_M1_2N H_DOUT_M2_2P GNDREF H_DOUT_M2_2N H_BCLK_2P GNDREF H_BCLK_2N H_TRG_2P GNDREF H_TRG_2N NC_08 NC_09 H_SCL0B_2 H_SDA0B_2 GNDREF Net-_HDMI_2-Pad18_ NC_10 GNDREF HDMI_A_1.4
U9 H_DOUT_M1_2P H_DOUT_M1_2N H_DOUT_M2_2P H_DOUT_M2_2N GNDREF EQ GNDREF 3.3V D_OUT_M2_2N D_OUT_M2_2P D_OUT_M1_2N D_OUT_M1_2P 3.3V 3.3V GNDREF 3.3V GNDREF DS25CP102TSQ
U6 BCLK_1P BCLK_1N TRG_1P TRG_1N GNDREF GNDREF GNDREF 3.3V H_TRG_1N H_TRG_1P H_BCLK_1N H_BCLK_1P 3.3V 3.3V PE 3.3V GNDREF DS25CP102TSQ
U7 BCLK_2P BCLK_2N TRG_2P TRG_2N GNDREF GNDREF GNDREF 3.3V H_TRG_2N H_TRG_2P H_BCLK_2N H_BCLK_2P 3.3V 3.3V PE 3.3V GNDREF DS25CP102TSQ
J2 GNDREF NC_11 NC_12 GNDREF GNDREF NC_13 NC_14 GNDREF GNDREF Net-_J2-PadC10_ Net-_J2-PadC11_ GNDREF GNDREF Net-_J2-PadC14_ Net-_J2-PadC15_ GNDREF GNDREF BCLK_1P BCLK_1N GNDREF GNDREF NC_15 NC_16 GNDREF GNDREF TRG_1P TRG_1N GNDREF GNDREF SCL0B_1 SDA0B_1 GNDREF GNDREF NC_17 NC_18 GNDREF NC_19 GNDREF 3.3V_FMC GNDREF NC_20 GNDREF GNDREF NC_21 NC_22 GNDREF GNDREF NC_23 NC_24 GNDREF NC_25 NC_26 GNDREF NC_27 NC_28 GNDREF NC_29 NC_30 GNDREF NC_31 NC_32 GNDREF NC_33 NC_34 GNDREF NC_35 NC_36 GNDREF NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 GNDREF NC_45 GNDREF NC_46 GNDREF NC_47 NC_48 GNDREF GNDREF NC_49 NC_50 GNDREF D_OUT_M1_2P D_OUT_M1_2N GNDREF D_OUT_M2_2P D_OUT_M2_2N GNDREF BCLK_2P BCLK_2N GNDREF TRG_2P TRG_2N GNDREF SCL0B_2 SDA0B_2 GNDREF SDA1B SCL1B GNDREF NC_51 NC_52 GNDREF NC_53 NC_54 GNDREF NC_55 NC_56 GNDREF NC_57 NC_58 GNDREF 2.5V_VADJ_FMC GNDREF NC_59 NC_60 GNDREF NC_61 NC_62 GNDREF NC_63 NC_64 GNDREF NC_65 NC_66 GNDREF NC_67 NC_68 GNDREF NC_69 NC_70 GNDREF NC_71 NC_72 GNDREF NC_73 NC_74 GNDREF NC_75 NC_76 GNDREF NC_77 NC_78 GNDREF NC_79 NC_80 GNDREF NC_81 NC_82 GNDREF NC_83 NC_84 GNDREF NC_85 ASP-134604-01
U8 H_DOUT_M1_1P H_DOUT_M1_1N H_DOUT_M2_1P H_DOUT_M2_1N GNDREF EQ GNDREF 3.3V Net-_J2-PadC10_ Net-_J2-PadC11_ Net-_J2-PadC14_ Net-_J2-PadC15_ 3.3V 3.3V GNDREF 3.3V GNDREF DS25CP102TSQ
R5 3.3V Net-_R5-Pad2_ 4.7k
R13 SCL0B_2 3.3V 4.7k
R4 3.3V Net-_R4-Pad2_ 4.7k
U5 H_SDA0B_2 SDA0B_2 GNDREF SCL0B_2 H_SCL0B_2 3.3V P82B715DR
U4 H_SDA0B_1 SDA0B_1 GNDREF SCL0B_1 H_SCL0B_1 3.3V P82B715DR
R12 SDA0B_2 3.3V 4.7k
R10 2.5V H_SDA0B_2 330
R11 2.5V H_SCL0B_2 330
R7 2.5V H_SCL0B_1 330
R9 SCL0B_1 3.3V 4.7k
R6 2.5V H_SDA0B_1 330
R8 SDA0B_1 3.3V 4.7k
C1 Net-_C1-Pad1_ GNDREF CP1
S1 2.5V_VADJ_FMC 2.5V 2.5V_Supply 3.3V_FMC 3.3V 3.3V_Supply JS202011SCQN
U1 GNDREF 3.3V_Supply Net-_C1-Pad1_ TLV1117-33
U2 GNDREF 2.5V_Supply Net-_C1-Pad1_ TLV1117-25
R2 3.3V SCL1B 4.7k
R1 3.3V SDA1B 4.7k
U3 Net-_R4-Pad2_ GNDREF GNDREF NC_86 PE EQ NC_87 GNDREF NC_88 NC_89 NC_90 NC_91 Net-_R5-Pad2_ SCL1B SDA1B 3.3V PCA9534DW
R14 3.3V Net-_HDMI_1-Pad18_ MICROSMD035F-2
R15 Net-_HDMI_2-Pad18_ 3.3V MICROSMD035F-2
.end
